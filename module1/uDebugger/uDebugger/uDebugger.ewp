# IAR project uDebugger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32L475xx; DEBUG
  ICCARM.CCIncludePath2: .\; Util; BSP; BSP\CMSIS; BSP\ST\StdPeripheralDrivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uDebugger.sim
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: BSP\layout.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group App
    App/: main.c
  group BSP
    BSP/: bsp.h bspLed.c bspLed.h bspUart.c bspUart.h datainit.c debugger.c discoveryboard.h hw_init.c hw_init.h interrupt.c layout.icf startup.s
  group BSP/CMSIS
    BSP/CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h mpu_armv7.h stm32l475xx.h stm32l4xx.h system_stm32l4xx.c system_stm32l4xx.h xcore_cmFunc.h xcore_cmInstr.h xcore_cmSimd.h
  group BSP/ST/StdPeripheralDrivers
    BSP/ST/StdPeripheralDrivers/: stm32l4xx_ll_bus.h stm32l4xx_ll_exti.c stm32l4xx_ll_exti.h stm32l4xx_ll_gpio.c stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.c stm32l4xx_ll_i2c.h stm32l4xx_ll_pwr.c stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.c stm32l4xx_ll_rcc.h stm32l4xx_ll_spi.c stm32l4xx_ll_spi.h stm32l4xx_ll_system.h stm32l4xx_ll_usart.c stm32l4xx_ll_usart.h stm32l4xx_ll_utils.c stm32l4xx_ll_utils.h
  group Util
    Util/: print.c print.h
